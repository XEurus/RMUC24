# Keil uVision project mcu_sdk_demo.uvprojx, settings and files
target deltaIII (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mcu_sdk_demo +hex
  c flags: OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Source\App;..\Source\HardDriver\inc;..\Source\STM32F10x_StdPeriph_Driver\inc;..\Source\startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../Source/App/: main.c Lidar.c
  group HardDriver
    ../Source/HardDriver/src/: Bsp_uart.c check.c
  group STARTUP
    ../Source/startup/: startup_stm32f10x_md.s startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    ../Source/STM32F10x_StdPeriph_Driver/src/: core_cm3.c misc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c stm32f10x_adc.c stm32f10x_it.c
